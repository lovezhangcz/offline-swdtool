# Keil uVision project OfflineDownloader.uvprojx, settings and files
target STM32_UCOSIII (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.10.0.3
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OfflineDownloader +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_HAL_DRIVER,STM32F103xB
  c include: .\STM32F10X_Lib_UCOSIII;.\SYSTEM\delay;.\SYSTEM\sys;.\UCOSIII\uCOS_CONFIG;.\UCOSIII\UCOS_BSP;.\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;.\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\UCOSIII\uCOS-III\Source;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;.\UCOSIII\uC-CPU;.\UCOSIII\uC-LIB;.\UCOSIII\uCOS-III;.\UCOSIII\uC-LIB\Ports;.\UCOSIII\uCOS-III\Ports;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic;.\USART;.\CAN;..\STM32C8T6_USB_CAN_Project;.\Encrypt;..\Encrypt_Project;..\Encrypt_Project_V2.0_2017.11.28;.\AES;.\CRC;.\ForSampleMain;.\STM32_FLASH;.\2_SPI;..\OfflineDownloaderV1.0_2017.12.08;.\W25Qxx;.\3_LCD1.8;.\4_STM32_TIMER;.\5_SWDModule;.\1_Key;.\6_Beep;.\7_SWIMModule;.\8_NewChip;..\OfflineDownloader-Release-V5.0;..\OfflineDownloader-Release-V5.0;.\10_app;.\11_rj_lib;.\12_teenyUSBStack\inc;.\12_teenyUSBStack\src;.\13_STM32F1xx_HAL_Driver\Inc;.\14_stm32f1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7c000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CFG
    ./10_app/: stm32f10x.h
  group Source
    ./STM32F10X_Lib_UCOSIII/: ClockConfigurationByCRJ.c core_cm3.c ForUCOSByCRJ.C startup_stm32f10x_hd.s
  group MAIN
    ./: main.c
    ./ForSampleMain/: ForSampleMain.c
  group USART
    ./USART/: STM32_USART.c
  group UCOSIII_BSP
    ./UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ./UCOSIII/uC-CPU/: cpu_core.c
    ./UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c
  group UCOSIII_LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ./UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ./UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.s os_cpu_c.c
  group UCOSIII_CONFIG
    ./UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group Encrypt
    ./Encrypt/: Encrypt_Code.C STM32F1xx_OPT.s
  group Attention
    ./: Attention.txt
  group CRC
    ./CRC/: STM32_CRC.C
  group AES
    ./AES/: AES_CRJ.c
  group FLASH
    ./STM32_FLASH/: STM32_FLASH.C
  group KEY
    ./1_Key/: KEY.c key_state_By_CRJ_V2.c
  group W25Qxx
    ./W25Qxx/: w25qxx.c memoryManage.c
  group SPI
    ./2_SPI/: stm32_spi.c
  group LCD18
    ./3_LCD1.8/: lcd1_8inch.c lcdFont.c lcdDisplay.c
  group TIMER
    ./4_STM32_TIMER/: stm32_timer_delay.c
  group SWDModule
    ./5_SWDModule/: SWD_Module.c
  group BeepCTL
    ./6_Beep/: BeepCTL.c
  group SWIM
    ./7_SWIMModule/: SWIM_Module.c STM8_Ifo.c
  group NewChip
    ./8_NewChip/: stm32lxx.c blueNRG_1.c STM8xx.c stm32l0xx.c stm32l4xx.c stm32f7xx.c
  group HID_TeenyStack
    ./12_teenyUSBStack/src/: teeny_usb.c stm32_fs_init.c teeny_usb_stm32_fs_device.c
  group HID_APP
    ./10_app/: hid_class.c teeny_usb_desc.c hid.c
